<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L432_ME3616.ewp</path>
  </project>
  <batchBuild />
</workspace>
