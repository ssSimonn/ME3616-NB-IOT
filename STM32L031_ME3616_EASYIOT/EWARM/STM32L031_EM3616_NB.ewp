# IAR project STM32L031_EM3616_NB.ewp, settings and files
configuration STM32L031_EM3616_NB (ARM, debug)
  General.OGChipSelectEditMenu: STM32L031K6 ST STM32L031K6
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 35
  General.FPU2: 0
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32L031xx
  ICCARM.CCIncludePath2: ../Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc; ../Drivers/STM32L0xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32L0xx/Include; ../Drivers/CMSIS/Include; ..\Drivers\ME3616\INC; ..\Drivers\EASYIOT\inc
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: STM32L031_EM3616_NB.hex
  ILINK.IlinkOutputFile: STM32L031_EM3616_NB.out
  ILINK.IlinkIcfFile: stm32l031xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32l031xx.s
  group Application/User
    ../Src/: dma.c gpio.c main.c stm32l0xx_hal_msp.c stm32l0xx_it.c usart.c
  group Drivers/CMSIS
    ../Src/: system_stm32l0xx.c
  group Drivers/EASYIOT
    ../Drivers/EASYIOT/src/: easyiot.c
  group Drivers/EM3616
    ../Drivers/ME3616/SRC/: me3616.c Me3616_app.c me3616_if.c
  group Drivers/STM32L0xx_HAL_Driver
    ../Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c
