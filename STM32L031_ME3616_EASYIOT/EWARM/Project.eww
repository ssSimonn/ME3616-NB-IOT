<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\STM32L031_EM3616_NB.ewp</path>
  </project>
  <batchBuild />
</workspace>
